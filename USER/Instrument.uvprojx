# Keil uVision project Instrument.uvprojx, settings and files
target Instrument (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Instrument +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10X_FWLIB\inc;..\BSP;..\Fatfs;..\STemWin\inc;..\STemWin\Config;..\FreeRTOS\include;..\FreeRTOS\prots\RVDS\ARM_CM3;..\BSP\DS18B20;..\BSP\delay;..\BSP\IWDG;..\BSP\PWR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c TaskManage.c MEMDEV_Banding.c sys.c iwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10X_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../BSP/: bsp_usart.c bsp_delay.c bsp_sdio_sdcard.c bsp_w25qxx.c bsp_can.c bsp_lcd7_0.c bsp_rtc.c bsp_timer.c bsp_ds18b20.c bsp_spi.c
    ../BSP/PWR/: bsp_pwr.c
  group Fatfs
    ../Fatfs/: diskio.c ff.c ffunicode.c
  group STemWin_Config
    ../STemWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../STemWin/OS/: GUI_X.c
  group STemWin_LIB
    ../STemWin/Lib/: STemWin_CM3_wc16_ARGB.a
  group Readme
    ../Readme/: can.txt doc.txt Fatfs.txt sdio.txt STemWin.txt
